# Keil uVision project Lector-v1.uvproj, settings and files
target Lector-v1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: PruebaLector
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: .\inc;.\STM32F0xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./src/: main.c stm32f0xx_it.c Lector_FSM.c terminal.c MyUARTS.c
  group Startup
    ./startup/: startup_stm32f0xx.s system_stm32f0xx.c
  group inc
    ./inc/: Lector_FSM.h MyUARTS.h terminal.h stm32f0xx_conf.h stm32f0xx_it.h
  group stdlib
    ./STM32F0xx_StdPeriph_Driver/inc/: stm32f0xx_gpio.h stm32f0xx_misc.h stm32f0xx_rcc.h stm32f0xx_usart.h
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_usart.c
